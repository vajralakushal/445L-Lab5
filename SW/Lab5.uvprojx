# Keil uVision project Lab5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab5.c DAC.h Switch.h Song.h DAC.c Switch.c Song.c
    ./lib/RGB/: RGB.c
    ./lib/TLV5616/: TLV5616.c
    ./inc/: LED.c startup.s LaunchPad.c Timer0A.c TExaS.c PLL.c Timer0A.h tm4c123gh6pm.h
